# Keil uVision project node2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: node2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware\delay;.\hardware\DHT11;.\hardware\NRF24L01
  group user
    ./user/: main.c
  group hardware
    ./hardware/delay/: delay.c
    ./hardware/DHT11/: DHT11.c
    ./hardware/NRF24L01/: nrf24l01.c
