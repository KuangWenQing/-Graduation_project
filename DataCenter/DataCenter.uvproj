# Keil uVision project DataCenter.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DataCenter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware\delay;.\hardware\ds1302;.\hardware\LCD12864C;.\hardware\NRF24L01
  group hardware
    ./hardware/delay/: delay.c
    ./hardware/ds1302/: ds1302.c
    ./hardware/LCD12864C/: lcd12864C.c
    ./hardware/NRF24L01/: nrf24l01.c
  group user
    ./user/: main.c
